# Repository kasbah/nomech_mini-hw

## KiCad design nomech_mini.kicad_pcb

Parts:
C1, C2, C6, C11, C12, C19: 100nF; SM0805
C3, C5, C7, C10: 4.7nF; SM0805
C4: 1uF; SM0805
C8, C9: 18pF; SM0805
C13, C14, C20: 10nF; SM0805
CON1: USB_2B; MICRO-B_USB
CON2: AVR-ISP-6; pin_array_3x2
D1: LED; SM0402
E1, E2, E3, E4, E5, E6, E7, E8, E9, E10, E11, E12, E13, E14, E15, E16: CAP-ELECTRODE; cap-electrode_16mm
GND1: TEST
L1, L2: FERRITE_BEAD; SM0805
P4: CONN_1; PIN_ARRAY_1
R1: 120R; SM0805
R2, R3, R4, R6, R8, R10, R12, R15: 1k; SM0805
R5, R11, R14, R16: 1M; SM0805
R7, R9: 22R; SM0805
R13: 10k; SM0805
U1: ATMEGA32U4; TQFP44
VCC1: TEST
X1: CRYSTAL_16MHz; adafruit-NX5032

Connections:
+5V: C11.1, C12.1, C13.1, C14.1, C19.1, C20.1, CON1.1, CON2.2, L1.1, L2.1, R1.1, R13.1, U1.2 (UVcc), U1.7 (VBus), U1.14 (VCC), U1.34 (VCC), VCC1.1, VCC1.2
/ISP_MISO: CON2.1, U1.11 (PB3(MISO))
/ISP_MOSI: CON2.4, U1.10 (PB2(MOSI))
/ISP_RST: CON2.5, R13.2, U1.13 (nRESET)
/ISP_SCK: CON2.3, U1.9 (PB1(SCLK))
AN_1: C3.1, R2.1, U1.40 (PF1(ADC1))
AN_2: C3.2, R5.1, U1.41 (PF0(ADC0))
AN_3: C5.1, R10.1, U1.38 (PF5(ADC5))
AN_4: C5.2, R11.1, U1.39 (PF4(ADC4))
AN_5: C7.1, R12.1, U1.36 (PF7(ADC7))
AN_6: C7.2, R14.1, U1.37 (PF6(ADC6))
AN_7: C10.1, R15.1, U1.28 (PB4(ADC11))
AN_8: C10.2, R16.1, U1.29 (PB5(ADC12))
GND: C1.1, C2.1, C4.2, C6.2, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C19.2, C20.2, CON1.5, CON2.6, D1.2 (K), GND1.1, GND1.2, U1.1 (PE6(AIN0)), U1.5 (UGnd), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND); also elsewhere on the board
LED_COLUMN_1: U1.21 (PD3(TXD1)); also elsewhere on the board
LED_COLUMN_2: U1.20 (PD2(RXD1)); also elsewhere on the board
LED_COLUMN_3: U1.19 (PD1(SDA)); also elsewhere on the board
LED_COLUMN_4: U1.18 (PD0(SCL)); also elsewhere on the board
LED_ROW_1: U1.25 (PD4(ADC8)); also elsewhere on the board
LED_ROW_2: U1.22 (PD5); also elsewhere on the board
LED_ROW_3: U1.26 (PD6(ADC9)); also elsewhere on the board
LED_ROW_4: U1.27 (PD7(ADC10)); also elsewhere on the board
unnamed: C2.2, U1.42 (AREF)
unnamed: C6.1, L2.2, U1.24 (AVCC)
unnamed: C4.1, U1.6 (UCap)
unnamed: C9.1, U1.17 (XTAL1), X1.2
unnamed: CON1.3, R9.1
unnamed: CON1.2, R7.1
unnamed: R7.2, U1.3 (D-)
unnamed: R9.2, U1.4 (D+)
unnamed: C1.2, L1.2, U1.44 (AVCC)
unnamed: R8.1, U1.33 (PE2)
unnamed: R6.1, U1.32 (PC7)
unnamed: R4.1, U1.31 (PC6)
unnamed: R3.1, U1.30 (PB6(ADC13))
unnamed 39: P4.1, U1.8 (PB0(SS)); also elsewhere on the board
unnamed: D1.1 (A), R1.2
unnamed: C8.1, U1.16 (XTAL2), X1.1
SLOPE: R5.2, R11.2, R14.2, R16.2, U1.12 (PB7)
X1: E1.1, E2.1, E3.1, E4.1, R3.2
X2: E5.1, E6.1, E7.1, E8.1, R4.2
X3: E9.1, E10.1, E11.1, E12.1, R6.2
X4: E13.1, E14.1, E15.1, E16.1, R8.2
Y1: E1.2, E5.2, E9.2, E13.2, R2.2
Y2: E2.2, E6.2, E10.2, E14.2, R10.2
Y3: E3.2, E7.2, E11.2, E15.2, R12.2
Y4: E4.2, E8.2, E12.2, E16.2, R15.2

Parts:
C15, C16, C17, C18: 1nF; SM0805
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: LED; SM0402
Q1, Q2, Q3, Q4: MOSFET_N; SOT23-NX7002AK
R17, R18, R19, R20, R22, R23, R24, R25, R28, R29, R30, R31, R34, R35, R36, R37: 120R; SM0805
R21, R27, R33, R39: 22R; SM0805
R26, R32, R38, R40: 4k7; SM0805

Connections:
GND: C15.2, C16.2, C17.2, C18.2, Q1.S, Q2.S, Q3.S, Q4.S, R26.1, R32.1, R38.1, R40.1; also elsewhere on the board
LED_COLUMN_1: R17.1, R22.1, R28.1, R34.1; also elsewhere on the board
LED_COLUMN_2: R18.1, R23.1, R29.1, R35.1; also elsewhere on the board
LED_COLUMN_3: R19.1, R24.1, R30.1, R36.1; also elsewhere on the board
LED_COLUMN_4: R20.1, R25.1, R31.1, R37.1; also elsewhere on the board
LED_ROW_1: R21.1; also elsewhere on the board
LED_ROW_1_SW: C15.1, D2.2 (K), D3.2 (K), D4.2 (K), D5.2 (K), Q1.D
LED_ROW_2: R27.1; also elsewhere on the board
LED_ROW_2_SW: C16.1, D6.2 (K), D7.2 (K), D8.2 (K), D9.2 (K), Q2.D
LED_ROW_3: R33.1; also elsewhere on the board
LED_ROW_3_SW: C17.1, D10.2 (K), D11.2 (K), D12.2 (K), D13.2 (K), Q3.D
LED_ROW_4: R39.1; also elsewhere on the board
LED_ROW_4_SW: C18.1, D14.2 (K), D15.2 (K), D16.2 (K), D17.2 (K), Q4.D
unnamed: D17.1 (A), R37.2
unnamed: Q2.G, R27.2, R32.2
unnamed: Q1.G, R21.2, R26.2
unnamed: D11.1 (A), R29.2
unnamed: D10.1 (A), R28.2
unnamed: D9.1 (A), R25.2
unnamed: D15.1 (A), R35.2
unnamed: D14.1 (A), R34.2
unnamed: D16.1 (A), R36.2
unnamed: D13.1 (A), R31.2
unnamed: D12.1 (A), R30.2
unnamed: Q3.G, R33.2, R38.2
unnamed: D8.1 (A), R24.2
unnamed: Q4.G, R39.2, R40.2
unnamed: D3.1 (A), R18.2
unnamed: D2.1 (A), R17.2
unnamed: D7.1 (A), R23.2
unnamed: D6.1 (A), R22.2
unnamed: D5.1 (A), R20.2
unnamed: D4.1 (A), R19.2

Board: 2 copper layers, 80.0 x 100.0 mm, 111 parts (16 on the bottom side), 71 nets.

Other parts of the board:
DP10080_v1: 100x80mm; dp_pcb-DP10080_V1_2
HOLE: 3.2mm; HOLE_3.2mm
HOLE#2, HOLE#3, HOLE#4: 3.2mm; HOLE_3.2mm
PB0: SPI_SS; PIN_ARRAY_1

Their connections:
unnamed 39: PB0.1; also elsewhere on the board

## Commit log

2013-04-09 adding gitignore
2013-04-09 doing basic layout estimation
2013-04-09 trying out LED position
2013-04-09 starting schematic, adjusting pcb
2013-04-09 starting LED array, adjusting PCB
2013-04-10 working mainly on LEDs
2013-04-10 messing about with elctrode
2013-04-10 adding netlist, just for messing with footprints
2013-04-10 commiting before change to LED numbers
2013-04-10 removing LEDs, adding switch
2013-04-11 starting layout
2013-04-11 laying out LEDs
2013-04-12 placing LEDS, working out laser cutting
2013-04-12 messing about with edge-cuts, putting them in .mod
2013-04-12 doing cutouts in the electrode module
2013-04-12 most Rs placed
2013-04-12 placed?
2013-04-13 starting routing...
2013-04-13 changing electrode
2013-04-17 working on layout
2013-04-17 reading qmatrix app notes
2013-05-04 adding a mess of libs
2013-05-07 laying out 4 types of LED+electrode combos
2013-05-07 starting to route
2013-05-07 routing...
2013-05-07 routing fan-out of atmega
2013-05-08 switching MCU and analog stuff
2013-05-08 grounding first
2013-05-14 changing electrodes to use fills, routing...
2013-05-14 settling on reverseLED and flipping everything
2013-05-14 routing..
2013-05-29 routing at 45 degrees
2013-05-29 routing, paying attention to looks on top layer
2013-05-29 routing... ugly but nice
2013-05-29 routing... nicely
2013-06-04 routing.. SPI done
2013-06-04 SPI tear-up and re-route
2013-06-06 routing, grounds on outside
2013-06-07 routing, smaller ground plane
2013-06-10 adding BOM, routing... ground planes
2013-06-10 some minor placing and routing corrections
2013-06-10 flipped the whole board, final touches 0.1-alpha
2013-06-10 adding gerbers and license
2013-06-10 plotting
2013-06-12 stitching ground plane, checking gerbers
2013-06-12 hiding some text, updating gerbers
2013-08-21 trying to sort out the dual atmega libs
2013-08-23 Rename nomech_mini.csv to nomech_mini.tsv
